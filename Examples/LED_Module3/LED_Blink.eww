<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LED_Blink.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\assignment03\Morse_Code\Morse_Code.ewp</path>
    </project>
    <batchBuild />
</workspace>
