<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\assignment02\Class_Demo\counter.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\HelloWorld.ewp</path>
    </project>
    <batchBuild />
</workspace>
